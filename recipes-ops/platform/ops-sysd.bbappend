# Copyright (C) 2016 Hewlett Packard Enterprise Development LP

PR_append = "_wedge_16x"

EXTRA_OECMAKE+="-DPLATFORM_WEDGE=ON -DUSE_SW_FRU=ON"
